# IAR project dpp-qk.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM7S64 Atmel AT91SAM7S64
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..; ..\..\..\..\..\include; ..\..\..\..\..\src; ..\..\..\..\..\ports\arm7-9\qk\iar; ..\..\..\..\..\3rd_party\at91sam7s-ek
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: dpp-qk.bin
  prebuild: cmd /c "if exist $OBJ_DIR$\qstamp.o del $OBJ_DIR$\qstamp.o"
  ILINK.IlinkOutputFile: dpp-qk.out
  ILINK.IlinkIcfFile: at91SAM7S64.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
configuration Spy (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: Q_SPY
  group Application
    ./: bsp.c
    ../../: dpp.h main.c philo.c table.c
    ../../../../../include/: qstamp.c
  group AT91SAM7S-EK
    ../../../../../3rd_party/at91sam7s-ek/iar/: low_level_init.c startup_at91mc.s
  group QP_ARM
    ../../../../../src/qf/: qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qeq.c qf_time.c
    ../../../../../src/qk/: qk.c
  group QP_port
    ../../../../../ports/arm7-9/qk/iar/: qep_port.h qf_port.h qk_port.h qk_port.s qs_port.h
  group QP_THUMB
    ../../../../../src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_qact.c qf_qmact.c
  group QS
    ../../../../../src/qs/: qs.c qs_64bit.c qs_fp.c qs_pkg.h qs_rx.c
