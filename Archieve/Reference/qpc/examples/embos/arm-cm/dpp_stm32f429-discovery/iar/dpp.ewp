# IAR project dpp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: SEGGER; ..\..\..\..\..\include; ..\..\..\..\..\src; ..\..\..\..\..\ports\embos; ..\..\..\..\..\3rd_party\embOS\Start\Inc; ..\..\..\..\..\3rd_party\stm32f4-discovery; ..\..\..\..\..\3rd_party\stm32f4-discovery\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: dpp.bin
  prebuild: cmd /c "if exist $OBJ_DIR$\qstamp.o del $OBJ_DIR$\qstamp.o"
  ILINK.IlinkOutputFile: dpp.out
  ILINK.IlinkIcfFile: dpp.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
configuration Spy (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: Q_SPY
  group Application
    ../: bsp.c bsp.h dpp.h main.c philo.c table.c
    ../../../../../include/: qstamp.c
  group embOS
    ../../../../../3rd_party/embOS/Start/Lib/: os7m_tlv_r.a
  group QP
    ../../../../../src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
    ../../../../../src/: qf_pkg.h
  group QP_port
    ../../../../../ports/embos/: qep_port.h qf_port.c qf_port.h qs_port.h
  group QS
    ../../../../../src/qs/: qs.c qs_64bit.c qs_fp.c qs_rx.c qutest.c
  group Setup
    Setup/: JLINKMEM_Process.c OS_Error.c RTOSInit_STM32F4xx.c
  group stm32f4-discovery
    ../../../../../3rd_party/stm32f4-discovery/iar/: startup_stm32f4xx.s
    ../../../../../3rd_party/stm32f4-discovery/: stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h
    ../../../../../3rd_party/stm32f4-discovery/src/: stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c
