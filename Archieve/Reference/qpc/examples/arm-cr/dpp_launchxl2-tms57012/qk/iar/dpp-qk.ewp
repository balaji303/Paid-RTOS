# IAR project dpp-qk.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TMS570LS1224PGE TexasInstruments TMS570LS1224PGE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 42
  General.FPU2: 3
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..; ..\..\..\..\..\include; ..\..\..\..\..\src; ..\..\..\..\..\ports\arm-cr\qk\iar; ..\..\..\..\..\3rd_party\launchxl2-tms57012\iar\include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: dpp-qk.bin
  prebuild: cmd /c "if exist $OBJ_DIR$\qstamp.o del $OBJ_DIR$\qstamp.o"
  ILINK.IlinkOutputFile: dpp-qk.out
  ILINK.IlinkIcfFile: dpp-qk.icf
  ILINK.IlinkProgramEntryLabel: _c_int00
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
configuration Spy (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: Q_SPY
  ICCARM.CCOptLevel: 1
  group Application
    ../: bsp.c main.c
    ../../: bsp.h dpp.h philo.c table.c
    ../../../../../include/: qstamp.c
  group launchxl2-tms57012
    ../../../../../3rd_party/launchxl2-tms57012/iar/source/: dabort.asm esm.c exceptions.c gio.c notification.c pinmux.c rti.c sci.c sys_core.asm sys_intvecs.asm sys_mpu.asm sys_phantom.c sys_pmu.asm sys_selftest.c sys_startup.c sys_vim.c system.c
  group QP
    ../../../../../src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
    ../../../../../src/: qf_pkg.h qk_pkg.h
    ../../../../../src/qk/: qk.c
  group QP_port
    ../../../../../ports/arm-cr/qk/iar/: qep_port.h qf_port.h qk_port.h qs_port.h
  group QS
    ../../../../../src/qs/: qs.c qs_fp.c qs_rx.c
    ../../../../../src/: qs_pkg.h
