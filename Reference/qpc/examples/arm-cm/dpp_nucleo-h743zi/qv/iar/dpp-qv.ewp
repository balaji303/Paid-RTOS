# IAR project dpp-qv.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32H743ZI ST STM32H743ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: STM32H743xx; USE_HAL_DRIVER; USE_STM32H7XX_NUCLEO_144
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..; ..\..\..\..\..\include; ..\..\..\..\..\src; ..\..\..\..\..\ports\arm-cm\qv\iar; ..\..\..\..\..\3rd_party\CMSIS\Include; ..\..\..\..\..\3rd_party\nucleo-h743zi; ..\..\..\..\..\3rd_party\nucleo-h743zi\Drivers\BSP\STM32H7xx_Nucleo_144; ..\..\..\..\..\3rd_party\nucleo-h743zi\Drivers\STM32H7xx_HAL_Driver\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: dpp-qv.bin
  prebuild: cmd /c "if exist $OBJ_DIR$\qstamp.o del $OBJ_DIR$\qstamp.o"
  ILINK.IlinkOutputFile: dpp-qv.out
  ILINK.IlinkIcfFile: C:\qp_lab\qpc\examples\arm-cm\dpp_nucleo-h743zi\qv\iar\dpp-qv.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STM32H743xx; USE_HAL_DRIVER; USE_STM32H7XX_NUCLEO_144
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: dpp-qv.icf
configuration Spy (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: Q_SPY; STM32H743xx; USE_HAL_DRIVER; USE_STM32H7XX_NUCLEO_144
  ILINK.IlinkIcfFile: dpp-qv.icf
  group Application
    ../: bsp.c main.c
    ../../: bsp.h dpp.h philo.c table.c
    ../../../../../include/: qstamp.c
  group nucleo-h743zi
    ../../../../../3rd_party/nucleo-h743zi/iar/: startup_stm32h743xx.s
    ../../../../../3rd_party/nucleo-h743zi/: stm32h743xx.h stm32h7xx.h system_stm32h7xx.c system_stm32h7xx.h
    ../../: stm32h7xx_hal_conf.h stm32h7xx_hal_msp.c
    ../../../../../3rd_party/nucleo-h743zi/Drivers/BSP/STM32H7xx_Nucleo_144/: stm32h7xx_nucleo_144.c stm32h7xx_nucleo_144.h
  group QP
    ../../../../../src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
    ../../../../../src/: qf_pkg.h
    ../../../../../src/qv/: qv.c
  group QP_port
    ../../../../../ports/arm-cm/qv/iar/: qv_port.c
  group QS
    ../../../../../src/qs/: qs.c qs_fp.c qs_rx.c
    ../../../../../src/: qs_pkg.h
  group STM32H7xx_HAL_Driver
    ../../../../../3rd_party/nucleo-h743zi/Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
